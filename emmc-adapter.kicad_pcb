# Repository Ryzzen/S40FC008-to-sd

File README.md:

# SkyHigh S40FC008 flash to sd-card

## KiCad design emmc-adapter.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric
C2, C3, C4: 1uF; C_0603_1608Metric
D1: Red LED; LED_0603_1608Metric
FID1, FID2, FID3: Fiducial; Fiducial_0.5mm_Mask1mm
J1: Micro_SD_Card; microSD_card
J2: Conn_01x12_Pin; PinHeader_1x12_P2.54mm_Vertical
R1: 10k; R_0603_1608Metric
U1: TLV70218_SOT23-5; SOT-23-5
V1: VOLTLOG_LOGO; voltlog_mask_3mm

Connections:
/!RST: J2.9, R1.2
/CLK: J1.5 (CLK), J2.5
/CMD: J1.3 (CMD), J2.3
/DAT0: J1.7 (DAT0), J2.7
/DAT1: J1.8 (DAT1), J2.8
/DAT2: J1.1 (DAT2), J2.1
/DAT3: J1.2 (DAT3/CD), J2.2
/VCC: C1.2, C2.1, D1.2 (A), J1.4 (VDD), R1.1, U1.1 (IN), U1.3 (EN)
/VCCQ: C3.1, J2.10, U1.5 (OUT)
/VDDI: C4.1, J2.12
GND: C2.2, C3.2, C4.2, D1.1 (K), J1.6 (VSS), J2.6, J2.11, U1.2 (GND)
unnamed: C1.1, J2.4

Board: 2 copper layers, 35.6 x 31.5 mm, 12 parts (12 on the bottom side), 12 nets.

File jlcpcb/production_files/BOM-emmc-adapter.csv:

Comment,Designator,Footprint,LCSC
1uF,"C2,C3,C4",C_0603_1608Metric,C15849
10uF,C1,C_0603_1608Metric,C1691
Red LED,D1,LED_0603_1608Metric,C2286
10k,R1,R_0603_1608Metric,C25804
Conn_01x12_Pin,J2,PinHeader_1x12_P2.54mm_Vertical,C2840012
TLV70218_SOT23-5,U1,SOT-23-5,C485152

## Commit log

2023-12-26 [ADD](General) schematics
2023-12-26 [DELETE](jlcpcb)
2023-12-26 [UPDATE](README) Added pictures
